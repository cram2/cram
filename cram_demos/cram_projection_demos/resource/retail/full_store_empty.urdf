Commit message: [demos] kukabot demo tweaks for real scanned store

File: cram_demos/cram_projection_demos/resource/retail/full_store_empty.urdf (robot description, URDF)
Before this commit: robot store, 115 links, 114 joints
Links:
- removed link world
Joints:
- removed joint world_to_root
